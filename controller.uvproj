# Keil uVision project controller.uvproj, settings and files
target Controller (ARM-ADS)
  device: STM32F417VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: controller +hex
  c flags: Optim=1
  c define: USE_HAL_DRIVER,STM32F417xx,USE_FULL_ASSERT
  c misc: --c99
  c include: .;.\FreeRTOS\Source;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\Keil\ARM_CM4F;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\header;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Drivers\STM32F4xx_HAL_Driver\Inc
  asm define: USE_HAL_DRIVER,STM32F407xx
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: startup_stm32f40xx.s
    ./sources/: main.c assert.c
  group FreeRTOS
    ./FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/Source/portable/MemMang/: heap_1.c
    ./FreeRTOS/Source/portable/Keil/ARM_CM4F/: port.c
  group header
    ./: FreeRTOSConfig.h
    ./header/: defs.h processor.h main.h
  group Drivers/CMSIS
    ./Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c
